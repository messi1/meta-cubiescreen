FILESPATH_prepend := "${THISDIR}/sunxi-board-fex:"

SRC_URI += "file://0001-cubieboard2-fex.patch"
