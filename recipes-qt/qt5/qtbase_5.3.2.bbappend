FILESPATH_prepend := "${THISDIR}/qtbase-5.3.2:"

SRC_URI += "file://0001-qeglfshooks-stub.patch"

